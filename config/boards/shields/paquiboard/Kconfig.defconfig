## config/boards/shields/paquiboard/Kconfig.defconfig
```kconfig
if SHIELD_PAQUIBOARD

config ZMK_KEYBOARD_NAME
    default "PaquiBoard"

config I2C
    default y

endif
```
